# Keil uVision project bmHttpServer.uvprojx, settings and files
target N32G45x (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: N32G457REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bmHttpServer +hex
  AfterMake: fromelf --bin --output=.\bin\bmHttpServer.bin .\Objects\bmHttpServer.axf
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER,SYSCLK_FREQ=100000000,USE_FULL_ASSERT=1
  c misc: --diag_suppress=68  --diag_suppress=111 --diag_suppress=550
  c include: ..\inc;..\src;..\src\arch;..\lwip\src\include;..\lwip\src;..\bsp\inc;..\lwip\src\include\lwip\apps;..\firmware\n32g45x_std_periph_driver\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\SADP;..\USR;..\Lwip_HTTPS;..\GUI;..\GUI\lvgl;..\GUI\lv_examples;..\GUI\lvgl_driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_gpio.c n32g45x_flash.c n32g45x_rcc.c n32g45x_tim.c n32g45x_usart.c n32g45x_adc.c
  group USER
    ../src/: main.c n32g45x_it.c
    ../USR/: bsp.c V_Timer.c usart.c typechange.c
  group BSP
    ../bsp/src/: log.c delay.c
    ../USR/: TFT.c Relay.c BL0942.c RS485.c EPROM.c CircularQueue.c Nbiot.c Key.c
  group GUI
    ../GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../GUI/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../GUI/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../GUI/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
    ../GUI/lvgl_driver/: lv_port_disp.c lv_port_indev.c
  group GUI_APP
    ../GUI/lv_examples/lv_apps/demo/: img_bubble_pattern.c demo.c
    ../GUI/lv_examples/lv_tests/lv_test_theme/: lv_test_theme_1.c
