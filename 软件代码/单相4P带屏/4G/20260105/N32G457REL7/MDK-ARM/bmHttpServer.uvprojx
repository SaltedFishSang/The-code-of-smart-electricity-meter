# Keil uVision project bmHttpServer.uvprojx, settings and files
target N32G45x (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: N32G457REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bmHttpServer +hex
  AfterMake: fromelf --bin --output=.\bin\bmHttpServer.bin .\Objects\bmHttpServer.axf
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER,SYSCLK_FREQ=100000000,USE_FULL_ASSERT=1
  c misc: --diag_suppress=68  --diag_suppress=111 --diag_suppress=550
  c include: ..\inc;..\src;..\src\arch;..\lwip\src\include;..\lwip\src;..\bsp\inc;..\lwip\src\include\lwip\apps;..\firmware\n32g45x_std_periph_driver\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\USR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_gpio.c n32g45x_flash.c n32g45x_rcc.c n32g45x_tim.c n32g45x_usart.c n32g45x_adc.c n32g45x_rtc.c n32g45x_bkp.c n32g45x_pwr.c
    ../../../20251230--不带Lvgl/N32G457REL7/firmware/n32g45x_std_periph_driver/src/: n32g45x_exti.c
  group USER
    ../src/: main.c n32g45x_it.c
    ../USR/: bsp.c V_Timer.c usart.c typechange.c RTC.c
  group BSP
    ../bsp/src/: log.c delay.c
    ../USR/: TFT.c Relay.c BL0942.c RS485.c EPROM.c CircularQueue.c Nbiot.c Key.c LCD_Display.c Modbus.c MQTT.c protection.c
