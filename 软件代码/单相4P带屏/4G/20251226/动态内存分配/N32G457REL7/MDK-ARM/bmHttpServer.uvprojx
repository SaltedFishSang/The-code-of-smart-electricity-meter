# Keil uVision project bmHttpServer.uvprojx, settings and files
target N32G45x (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: N32G457REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bmHttpServer +hex
  AfterMake: fromelf --bin --output=.\bin\bmHttpServer.bin .\Objects\bmHttpServer.axf
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: N32G45X, USE_STDPERIPH_DRIVER,SYSCLK_FREQ=100000000,USE_FULL_ASSERT=1
  c include: ..\inc;..\src;..\src\arch;..\lwip\src\include;..\lwip\src;..\bsp\inc;..\lwip\src\include\lwip\apps;..\firmware\n32g45x_std_periph_driver\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\SADP;..\USR;..\Lwip_HTTPS;..\lvgl-9.4.0\src;..\lvgl-9.4.0\examples\porting;..\lvgl-9.4.0;..\GUI_APP;..\lvgl-9.4.0\demos;..\lvgl-9.4.0\demos\music;..\GUI_APP\custom;..\GUI_APP\generated
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_gpio.c n32g45x_flash.c n32g45x_rcc.c n32g45x_tim.c n32g45x_usart.c n32g45x_adc.c
  group USER
    ../src/: main.c n32g45x_it.c
    ../USR/: bsp.c V_Timer.c usart.c typechange.c
  group BSP
    ../bsp/src/: log.c delay.c
    ../USR/: TFT.c Relay.c BL0942.c RS485.c EPROM.c CircularQueue.c Nbiot.c Key.c
  group Lvgl/Config
    ../lvgl-9.4.0/: lv_conf.h lv_version.h lvgl.h lvgl_private.h
  group Lvgl/Porting
    ../lvgl-9.4.0/examples/porting/: lv_port_disp.c lv_port_indev.c
  group Lvgl/Src
    ../lvgl-9.4.0/src/: lv_init.c
  group Lvgl/Src/Core
    ../lvgl-9.4.0/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group Lvgl/Src/Display
    ../lvgl-9.4.0/src/display/: lv_display.c
  group Lvgl/Src/Draw
    ../lvgl-9.4.0/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../lvgl-9.4.0/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../lvgl-9.4.0/src/draw/convert/: lv_draw_buf_convert.c
    ../lvgl-9.4.0/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../lvgl-9.4.0/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../lvgl-9.4.0/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../lvgl-9.4.0/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../lvgl-9.4.0/src/draw/opengles/: lv_draw_opengles.c
    ../lvgl-9.4.0/src/draw/sdl/: lv_draw_sdl.c
    ../lvgl-9.4.0/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../lvgl-9.4.0/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../lvgl-9.4.0/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../lvgl-9.4.0/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../lvgl-9.4.0/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group Lvgl/Src/Indev
    ../lvgl-9.4.0/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group Lvgl/Src/Layouts
    ../lvgl-9.4.0/src/layouts/flex/: lv_flex.c
    ../lvgl-9.4.0/src/layouts/grid/: lv_grid.c
    ../lvgl-9.4.0/src/layouts/: lv_layout.c
  group Lvgl/Src/Libs
    ../lvgl-9.4.0/src/libs/barcode/: code128.c lv_barcode.c
    ../lvgl-9.4.0/src/libs/bin_decoder/: lv_bin_decoder.c
    ../lvgl-9.4.0/src/libs/bmp/: lv_bmp.c
    ../lvgl-9.4.0/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../lvgl-9.4.0/src/libs/ffmpeg/: lv_ffmpeg.c
    ../lvgl-9.4.0/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../lvgl-9.4.0/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../lvgl-9.4.0/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../lvgl-9.4.0/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../lvgl-9.4.0/src/libs/gif/AnimatedGIF/src/: gif.c
    ../lvgl-9.4.0/src/libs/gif/: lv_gif.c
    ../lvgl-9.4.0/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../lvgl-9.4.0/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    ../lvgl-9.4.0/src/libs/gstreamer/: lv_gstreamer.c
    ../lvgl-9.4.0/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../lvgl-9.4.0/src/libs/libpng/: lv_libpng.c
    ../lvgl-9.4.0/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../lvgl-9.4.0/src/libs/lz4/: lz4.c
    ../lvgl-9.4.0/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../lvgl-9.4.0/src/libs/rle/: lv_rle.c
    ../lvgl-9.4.0/src/libs/rlottie/: lv_rlottie.c
    ../lvgl-9.4.0/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../lvgl-9.4.0/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../lvgl-9.4.0/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../lvgl-9.4.0/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../lvgl-9.4.0/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../lvgl-9.4.0/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
  group Lvgl/Src/Misc
    ../lvgl-9.4.0/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../lvgl-9.4.0/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../lvgl-9.4.0/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../lvgl-9.4.0/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group Lvgl/Src/Osal
    ../lvgl-9.4.0/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group Lvgl/Src/Other
    ../lvgl-9.4.0/src/others/file_explorer/: lv_file_explorer.c
    ../lvgl-9.4.0/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../lvgl-9.4.0/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgl-9.4.0/src/others/gridnav/: lv_gridnav.c
    ../lvgl-9.4.0/src/others/ime/: lv_ime_pinyin.c
    ../lvgl-9.4.0/src/others/imgfont/: lv_imgfont.c
    ../lvgl-9.4.0/src/others/monkey/: lv_monkey.c
    ../lvgl-9.4.0/src/others/observer/: lv_observer.c
    ../lvgl-9.4.0/src/others/snapshot/: lv_snapshot.c
    ../lvgl-9.4.0/src/others/sysmon/: lv_sysmon.c
    ../lvgl-9.4.0/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../lvgl-9.4.0/src/others/translation/: lv_translation.c
    ../lvgl-9.4.0/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../lvgl-9.4.0/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    ../lvgl-9.4.0/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
  group Lvgl/Src/Stdlib
    ../lvgl-9.4.0/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../lvgl-9.4.0/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../lvgl-9.4.0/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../lvgl-9.4.0/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../lvgl-9.4.0/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../lvgl-9.4.0/src/stdlib/: lv_mem.c
  group Lvgl/Src/Themes
    ../lvgl-9.4.0/src/themes/default/: lv_theme_default.c
    ../lvgl-9.4.0/src/themes/mono/: lv_theme_mono.c
    ../lvgl-9.4.0/src/themes/simple/: lv_theme_simple.c
    ../lvgl-9.4.0/src/themes/: lv_theme.c
  group Lvgl/Src/Tick
    ../lvgl-9.4.0/src/tick/: lv_tick.c
  group Lvgl/Src/Widgets
    ../lvgl-9.4.0/src/widgets/3dtexture/: lv_3dtexture.c
    ../lvgl-9.4.0/src/widgets/animimage/: lv_animimage.c
    ../lvgl-9.4.0/src/widgets/arc/: lv_arc.c
    ../lvgl-9.4.0/src/widgets/arclabel/: lv_arclabel.c
    ../lvgl-9.4.0/src/widgets/bar/: lv_bar.c
    ../lvgl-9.4.0/src/widgets/button/: lv_button.c
    ../lvgl-9.4.0/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../lvgl-9.4.0/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl-9.4.0/src/widgets/canvas/: lv_canvas.c
    ../lvgl-9.4.0/src/widgets/chart/: lv_chart.c
    ../lvgl-9.4.0/src/widgets/checkbox/: lv_checkbox.c
    ../lvgl-9.4.0/src/widgets/dropdown/: lv_dropdown.c
    ../lvgl-9.4.0/src/widgets/image/: lv_image.c
    ../lvgl-9.4.0/src/widgets/imagebutton/: lv_imagebutton.c
    ../lvgl-9.4.0/src/widgets/keyboard/: lv_keyboard.c
    ../lvgl-9.4.0/src/widgets/label/: lv_label.c
    ../lvgl-9.4.0/src/widgets/led/: lv_led.c
    ../lvgl-9.4.0/src/widgets/line/: lv_line.c
    ../lvgl-9.4.0/src/widgets/list/: lv_list.c
    ../lvgl-9.4.0/src/widgets/lottie/: lv_lottie.c
    ../lvgl-9.4.0/src/widgets/menu/: lv_menu.c
    ../lvgl-9.4.0/src/widgets/msgbox/: lv_msgbox.c
    ../lvgl-9.4.0/src/widgets/objx_templ/: lv_objx_templ.c
    ../lvgl-9.4.0/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../lvgl-9.4.0/src/widgets/roller/: lv_roller.c
    ../lvgl-9.4.0/src/widgets/scale/: lv_scale.c
    ../lvgl-9.4.0/src/widgets/slider/: lv_slider.c
    ../lvgl-9.4.0/src/widgets/span/: lv_span.c
    ../lvgl-9.4.0/src/widgets/spinbox/: lv_spinbox.c
    ../lvgl-9.4.0/src/widgets/spinner/: lv_spinner.c
    ../lvgl-9.4.0/src/widgets/switch/: lv_switch.c
    ../lvgl-9.4.0/src/widgets/table/: lv_table.c
    ../lvgl-9.4.0/src/widgets/tabview/: lv_tabview.c
    ../lvgl-9.4.0/src/widgets/textarea/: lv_textarea.c
    ../lvgl-9.4.0/src/widgets/tileview/: lv_tileview.c
    ../lvgl-9.4.0/src/widgets/win/: lv_win.c
  group Lvgl/Src/Fonts
    ../lvgl-9.4.0/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group GUI_APP
    ../GUI_APP/custom/: custom.c custom.h lv_conf_ext.h
    ../GUI_APP/generated/guider_fonts/: lv_font_Acme_Regular_13.c lv_font_Alatsi_Regular_13.c lv_font_Alatsi_Regular_14.c lv_font_Alatsi_Regular_17.c lv_font_Alatsi_Regular_23.c lv_font_Alatsi_Regular_26.c lv_font_Alatsi_Regular_40.c
    ../GUI_APP/generated/: events_init.c gui_guider.c setup_scr_Game2048.c widgets_init.c
