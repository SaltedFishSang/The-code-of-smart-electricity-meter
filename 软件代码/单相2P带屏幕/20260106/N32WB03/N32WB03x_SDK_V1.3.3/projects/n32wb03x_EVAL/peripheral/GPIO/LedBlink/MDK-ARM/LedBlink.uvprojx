# Keil uVision project LedBlink.uvprojx, settings and files
target N32WB03X (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: LedBlink +hex
  AfterMake: fromelf --bin --output=.\bin\LedBlink.bin .\Objects\LedBlink.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb03x_std_periph_driver\inc;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x1ffff
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../../../../../../firmware/n32wb03x_std_periph_driver/src/: n32wb03x_usart.c n32wb03x_gpio.c n32wb03x_rcc.c n32wb03x_tim.c misc.c n32wb03x_exti.c n32wb03x_lpuart.c n32wb03x_rtc.c n32wb03x_qflash.c
    ../src/: n32wb03x_it.c
  group USER
    ../src/: main.c
    ../USER/: BSP.c TImer.c Usart.c V_Timer.c Relay.c BL0942.c Nbiot.c CircularQueue.c typechange.c Modbus.c RTC.c Flash.c MQTT.c protection.c oled.c oledfont.h Display.c
  group DOC
    ../: readme.txt
