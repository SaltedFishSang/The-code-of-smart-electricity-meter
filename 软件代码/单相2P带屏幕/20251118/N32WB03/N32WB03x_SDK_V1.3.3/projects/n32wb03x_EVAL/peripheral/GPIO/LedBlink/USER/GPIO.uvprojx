# Keil uVision project GPIO.uvprojx, settings and files
target GPIO (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\mh210xLib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c mh210x_it.c BSP.c Motor.c Timer.c Vtimer.c ATT7053CU.c Control.c EPROM.c Modbus.c Temp.c RTC.c protection.c Uart.c MQTT.c Nbiot.c typechange.c CircularQueue.c
    ../../../../Libraries/mh210xLib/src/: system_mh210x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_mh210x.s
  group FWLib
    ../../../../Libraries/mh210xLib/src/: misc.c mh210x_rcc.c mh210x_gpio.c mh210x_usart.c
    ../../../../Libraries/MH210xLib/src/: mh210x_tim.c mh210x_exti.c mh210x_adc.c mh210x_dma.c mh210x_rtc.c mh210x_bkp.c mh210x_pwr.c
